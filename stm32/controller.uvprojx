# Keil uVision project controller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030, USE_STDPERIPH_DRIVER
  c include: .\hal;.\hal\STM32F0xx_StdPeriph_Driver\inc;.\Include;.\driver\button;.\driver\motor;.\driver\serial;.\driver\timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StdLib
    ./hal/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_rcc.c
    ./hal/: system_stm32f0xx.c startup_stm32f030.s
  group drivers
    ./driver/button/: button.c
    ./driver/motor/: motor.c
    ./driver/serial/: serial.c
    ./driver/timer/: timer.c
  group src
    ./src/app/: main.c
